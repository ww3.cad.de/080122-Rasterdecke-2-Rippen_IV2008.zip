# Autodesk Inventor part: Rasterdecke-2-Rippen
## iProperties
Created: 2008-01
Part Number: Rasterdecke-2-Rippen
Document SubType Name: Modeling
Designer: sec
Density: 1 g/cm^3
Author: sec
